# Repository Galvant/automation-pcb

## KiCad design automation-pcb.kicad_pcb

Parts:
C1, C3: 10uF/16V
C2, C6, C7, C8, C9, C12, C13, C15, C16, C17, C18, C19, C20, C25, C33, C35, C41: 0.1uF
C5: 0.01uF
C11, C14: 18pF
C26, C30, C31, C32: 1uF
C28: 12uF
C34: 0.22uF
C36, C39: 1000pF
C40: 470pF
C42: 100uF
C43: 15nF
C44: 1000uF
C45: 560pF
CP1, CP2: C_PACK4
D7: 1N4148W
D8: DFLT15A
D11: PDS1040
D12, D13, D14, D15: LED
IC1: ATMEGA328P-A; TQFP32
IP1: I_PACK4
L1, L2: 1uH, 250mA
L7: 1uH
P1: CONN_3X2
P2: CONN_10
P3, P4: CONN_6
R1: 300
R2, R3: 330
R4, R27: 12k
R9: 1M
R10, R11: 10K
R12, R26: 10k
R13: 127
R14: 25.5k
R15, R16: 2.2k
R17: 100
R18: 4.99k
R19: 10
R20: 2.05k
R25: 3.01k
R28: 20k
RP1, RP3: 49.9
RP2: 470
T1: TRANSFO_FA2924
U1: W5100; MODULE
U2: MAGJACK; MODULE
U3: SI3402; MODULE
U4: 24AA025E48; MODULE
U5: PS2911; MODULE
U6: TLV431; MODULE
U7, U8: BAV99; MODULE
X1: 25MHz

Connections:
1V8A: C13.1, L2.1, U1.7 (VCC1V8A), U1.74 (VCC1V8A)
+1.8V: C2.1, C6.1, C8.1, L2.2, U1.11 (1V8_OUT), U1.15 (VCC1V8D), U1.16 (VCC1V8D), U1.33 (VCC1V8D), U1.69 (VCC1V8D)
+3.3V: C1.1, C7.1, C15.1, C16.1, C17.1, C18.1, C19.1, C35.1, C39.2, C44.1, IC1.4 (VCC), IC1.6 (VCC), IC1.18 (AVCC), IC1.20 (AREF), L1.1, L7.2, P1.2, P4.4, R2.2, R3.2, R10.2, R11.2, R12.1, R15.1, R16.2, RP2.5 (R4), RP2.6 (R3), RP2.7 (R2), RP2.8 (R1), U1.12 (VCC3V3D), U1.18 (VCC3V3D), U1.44 (VCC3V3D), U2.7, U4.6 (Vcc)
A0: IC1.23 ((PCINT8/ADC0)PC0), P3.1
A1: IC1.24 ((PCINT9/ADC1)PC1), P3.2
A2: IC1.25 ((PCINT10/ADC2)PC2), P3.3
A3: IC1.26 ((PCINT11/ADC3)PC3), P3.4
COLLED: D14.2 (K), U1.71 (COLLED)
D0: IC1.30 ((PCINT16/RXD)PD0), P2.1, P4.3
D1: IC1.31 ((PCINT17/TXD)PD1), P2.2, P4.2
D2: IC1.32 ((PCINT18/INT0)PD2), P2.3
D3: IC1.1 ((PCINT19/OC2B/INT1)PD3), P2.4
D4: IC1.2 ((PCINT20/XCK/T0)PD4), P2.5
D5: IC1.9 ((PCINT21/OC0B/T1)PD5), P2.6
D6: IC1.10 ((PCINT22/OC0A/AIN0)PD6), P2.7
D7: IC1.11 ((PCINT23/AIN1)PD7), P2.8
D8: IC1.12 ((PCINT0/CLKO/ICP1)PB0), P2.9
D9: IC1.13 ((PCINT1/OC1A)PB1), P2.10
DTR: C41.2, P4.1
FDXLED: D15.2 (K), U1.70 (FDXLED)
GND: C1.2, C2.2, C3.2, C5.2, C6.2, C7.2, C8.2, C9.2, C11.1, C12.2, C13.2, C14.1, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C35.2, C36.2, C42.2, C44.2, IC1.3 (GND), IC1.5 (GND), IC1.21 (GND), P1.6, P4.6, R1.1, R27.2, T1.9 (OUT1B), T1.10 (OUT2B), U1.4 (GNDA), U1.10 (GNDA), U1.13 (GNDD), U1.14 (GNDD), U1.17 (GNDD), U1.19 (DATA7), U1.20 (DATA6), U1.21 (DATA5), U1.22 (DATA4), U1.23 (DATA3), U1.24 (DATA2), U1.25 (DATA1), U1.26 (DATA0), U1.32 (GNDD), U1.34 (TEST_MODE3), U1.35 (TEST_MODE2), U1.36 (TEST_MODE1), U1.37 (TEST_MODE0), U1.38 (ADDR14), U1.39 (ADDR13), U1.40 (ADDR12), U1.41 (ADDR11), U1.42 (ADDR10), U1.43 (GNDD), U1.45 (ADDR9), U1.46 (ADDR8), U1.47 (ADDR7), U1.48 (ADDR6), U1.49 (ADDR5), U1.50 (ADDR4), U1.51 (ADDR3), U1.52 (ADDR2), U1.53 (ADDR1), U1.54 (ADDR0), U1.63 (OPMODE0), U1.64 (OPMODE1), U1.65 (OPMODE2), U1.68 (GNDD), U1.77 (GNDA), U4.2 (Vss), U4.4 (A1), U4.5 (A0), U6.3 (ANODE)
LINKLED: U1.66 (LINKLED), U2.14
MISO: IC1.16 ((PCINT4/MISO)PB4), P1.1, U1.27 (MISO)
MOSI: IC1.15 ((PCINT3/OC2A/MOSI)PB3), P1.4, U1.28 (MOSI)
unnamed: R3.1, U2.12
unnamed: R2.1, U2.15
unnamed: R10.1, U1.31 (SEN)
unnamed: R20.2, U5.1 (ANODE)
unnamed: U3.7 (HSO), U3.17 (VSS1), U3.19 (VSS2)
unnamed: C40.1, D11.1 (A), T1.7 (OUT1A), T1.8 (OUT2A)
unnamed: C43.1, U5.2 (CATHODE), U6.2 (CATHODE)
unnamed: C31.1, U3.4 (ISOSSFT)
unnamed: R17.1, R18.2, U3.1 (EROUT), U5.4 (COLLECTOR)
unnamed: C33.1, R18.1, U3.3 (VDD)
unnamed: R1.2, R4.1
unnamed: R4.2, U1.1 (RSET_BG)
unnamed: C11.2, R9.1, U1.76 (XTLP), X1.1
unnamed: C14.2, R9.2, U1.75 (XTLN), X1.2
unnamed: R11.1, U1.55 (/CS), U1.57 (/WR), U1.58 (/RD)
unnamed: D14.1 (A), RP2.3
unnamed: D15.1 (A), RP2.4
unnamed: D13.1 (A), RP2.2
unnamed: D12.1 (A), RP2.1
unnamed: R14.1, U3.6 (RDET)
unnamed: R13.1, U3.8 (RCL)
unnamed: C12.1, RP3.1, RP3.2
unnamed: C9.1, RP1.1, RP1.2
unnamed: C3.1, C5.1, L1.2, U1.2 (VCC3V3A)
unnamed: C40.2, R19.1
unnamed: D7.1 (A), D8.1 (A)
unnamed: C42.1, D11.2 (K), L7.1, R19.2
unnamed: C45.2, R25.1
unnamed: C26.2, C28.2, C30.2, C32.2, D8.2 (K), T1.2 (IN-), U3.18 (SWO)
unnamed: C34.1, R17.2
unnamed: R25.2, R26.2, R27.1, R28.2, U6.1 (REF)
unnamed: C45.1, R20.1, R28.1
unnamed: C43.2, R26.1
RESET: C20.1, C41.1, IC1.29 ((PCINT14/~RESET~)PC6), P1.5, R12.2
RXIN: RP3.4 (R1), U1.6 (RXIN), U2.8
RXIP: RP3.3 (R2), U1.5 (RXIP), U2.1
RXLED: D13.2 (K), U1.72 (RXLED)
SCK: IC1.17 ((PCINT5/SCK)PB5), P1.3, U1.30 (SCLK)
SCL: IC1.28 ((PCINT14/SCL/ADC5)PC5), P3.6, R15.2, U4.1 (SCL)
SDA: IC1.27 ((PCINT12/SDA/ADC4)PC4), P3.5, R16.1, U4.3 (SDA)
SPDLED: U1.67 (SPDLED), U2.13
SS: IC1.14 ((PCINT2/OC1B/~SS~)PB2), U1.29 (/SCS)
TXLED: D12.2 (K), U1.73 (TXLED)
TXON: RP1.4 (R1), U1.9 (TXON), U2.9
TXOP: RP1.3 (R2), U1.8 (TXOP), U2.2
V1+: CP1.8 (R1), CP2.1, IP1.8 (R1), U3.11 (SP1), U7.3 (P2_M)
V1+j: IP1.1, U2.11
V1-: CP1.7 (R2), CP2.2, IP1.7 (R2), U3.10 (SP2), U7.6 (P1_M)
V1-j: IP1.2, U2.6
V2+: CP1.6 (R3), CP2.3, IP1.6 (R3), U3.14 (CT1), U8.6 (P1_M)
V2+j: IP1.3, U2.5
V2-: CP1.5 (R4), CP2.4, IP1.5 (R4), U3.13 (CT2), U8.3 (P2_M)
V2-j: IP1.4, U2.10
VSSA: C31.2, C33.2, C34.2, U3.15 (VSSA), U5.3 (EMITTER)
Vneg: C25.2, C36.1, CP1.1, CP1.2, CP1.3, CP1.4, R13.2, U3.9 (VNEG), U7.1 (P1_A), U7.4 (P2_A), U8.1 (P1_A), U8.4 (P2_A)
Vposf: C25.1, C26.1, C28.1, C30.1, C32.1, C39.1, CP2.5 (R4), CP2.6 (R3), CP2.7 (R2), CP2.8 (R1), D7.2 (K), R14.2, T1.1 (IN+), U3.2 (SSFT), U3.12 (VPOSF), U3.16 (VPOSS), U3.20 (FB), U7.2 (P1_C), U7.5 (P2_K), U8.2 (P1_C), U8.5 (P2_K)

Notes on the sheet:
U1/pin15
U1/pin33
U1/pin69
U1/pin7
U1/pin74
U1/pin12
U1/pin18
U1/pin44
1.24V*(1+20k/12k)=3.3V
Power protection and filtering
ICSP
PoE Classification Resistor
127ohm->Class 1 0.44 to 3.84 W
FTDI Cable Header
Digikey:24AA025E48T-I/OTCT-ND
EEPROM holding valid EUI-48 address
Header Pins
IC1/pin4
IC1/pin6
D7: Digikey 1N4148WSFSCT-ND
SOT-363

Board: 2 copper layers, 86.9 x 51.8 mm, 84 parts (0 on the bottom side), 80 nets.

## Commit log

2013-09-29 Initial commit of files
